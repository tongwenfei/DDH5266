# IAR project stm8_lcd.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_HD_VL
  ICCSTM8.CCIncludePath2: head; src; USER\inc; CMSIS
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8_lcd.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group CMSIS
    CMSIS/: stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
  group head
    head/: stm8l15x.h stm8l15x_clk.h stm8l15x_gpio.h stm8l15x_lcd.h stm8l15x_rtc.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h
  group src
    src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_lcd.c stm8l15x_rtc.c stm8l15x_syscfg.c stm8l15x_tim2.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c
  group USER
    USER/src/: adc.c delay.c eeprom.c Event.c key.c lcd.c led.c main.c sys.c SystemPara.c uart.c usart.c
    USER/inc/: Temputerature.h
